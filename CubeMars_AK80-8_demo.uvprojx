# Keil uVision project CubeMars_AK80-8_demo.uvprojx, settings and files
target CubeMars_AK80-8_demo (6210000::V6.21::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CubeMars_AK80-8_demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\CMSIS\Include;Drivers\STM32F4xx_HAL_Driver\Inc;RTE\_Template;.eide\deps;Drivers\bsp\Inc;Drivers\system\Inc;Middlewares\Inc;Application\Inc
  asm define: USE_HAL_DRIVER,STM32F429xx
  library: MicroLIB
  memory RVCT1: ROM 0x08000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x5000
  group Startup
    Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Readme
    ./: README.md
  group Middleware
    Middlewares/Src/: pid.cpp
  group Drivers/system
    Drivers/system/Src/: delay.c sys.c
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal.c stm32f4xx_ll_fmc.c
  group Drivers/bsp
    Drivers/bsp/Src/: ak80.c buffer_append.c can.c key.c led.c usart.c
  group Application
    Application/Src/: main.c stm32f4xx_it.c
    Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
